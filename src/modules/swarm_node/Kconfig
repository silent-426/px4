## src/modules/swarm_node/Kconfig
```kconfig
menuconfig MODULES_SWARM_NODE
	bool "swarm_node"
	default n
	---help---
		Enable support for swarm_node
```
